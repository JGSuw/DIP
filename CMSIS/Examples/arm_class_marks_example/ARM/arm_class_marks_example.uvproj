# Keil uVision project arm_class_marks_example.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: TMS570LS20216 Texas Instruments
  cpu: IRAM(0x08000000-0x08027FFF) IROM(0-0x001FFFFF) CLOCK(16000000) CPUTYPE("Cortex-R4F") EBIG
  output: arm_class_marks_example
  c flags: Optim=3 oTime=1
  c define: MDK_TMS_570,UART_SUPPORT
  c include: ..\..\..\Include
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x8008000 size 0x20000
  group Source Group 1
    ../: arm_class_marks_example_f32.c
    ../../../Lib/: arm_math_Cortex_R4_bspf.lib
  group Startup Files
    ../../DeviceSupport/ARM/MDK/Source/: Retarget.c system.c startup_TMS570LS.s Serial.c
