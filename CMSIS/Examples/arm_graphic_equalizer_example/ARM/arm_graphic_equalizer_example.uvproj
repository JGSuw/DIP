# Keil uVision project arm_graphic_equalizer_example.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: TMS570LS20216 Texas Instruments
  cpu: IRAM(0x08000000-0x08027FFF) IROM(0-0x001FFFFF) CLOCK(16000000) CPUTYPE("Cortex-R4F") EBIG
  output: arm_graphic_equalizer_example
  c flags: Optim=3 oTime=1
  c define: MDK_TMS_570,UART_SUPPORT
  c include: ..\..\..\Include;..\..\HelperFunc\Include
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x8008000 size 0x20000
  group Source Group 1
    ../../../Lib/: arm_math_Cortex_R4_bspf.lib
    ../: arm_graphic_equalizer_data.c arm_graphic_equalizer_example_q31.c
    ../../HelperFunc/Source/: math_helper.c
  group Startup Files
    ../../DeviceSupport/ARM/MDK/Source/: Retarget.c system.c startup_TMS570LS.s Serial.c
